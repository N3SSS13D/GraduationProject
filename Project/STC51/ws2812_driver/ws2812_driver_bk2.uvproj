# Keil uVision project ws2812_driver_bk2.uvproj, settings and files
target ws2812_driver (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ws2812_driver +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group app
    ./Sources/app/: app.c
  group drv
    ./Sources/drv/: ws2812_drv.c hc595_drv.c
  group AiCube
    ./Sources/drv/: main.c port.c timer.c exti.c pwm.c usblib.c
    ./Sources/lib/: stc_usb_cdc_32g.lib
