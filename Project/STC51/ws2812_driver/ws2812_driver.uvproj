# Keil uVision project ws2812_driver.uvproj, settings and files
target ws2812_driver (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ws2812_driver +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group app
    ./Sources/app/: app.c
  group drv
    ./Sources/drv/: ws2812_drv.c hc595_drv.c gp_led_matrix_ai8051u.c gp_led_matrix_bt_debug.c gp_led_matrix_usb_debug.c
  group mid
    ./Sources/mid/: mid_task.c key_ctrl.c draw_drv.c offline_pattern.c gp_led_action.c local_display_scheme.c rtc_clock.c
  group AiCube
    ./Sources/drv/: main.c port.c timer.c exti.c pwm.c usblib.c uart.c
    ./Sources/lib/: stc_usb_cdc_32g.lib
