# Keil uVision project UCOS_STC32G.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UCOS_STC32G +hex
  link misc: REMOVEUNUSED
  group UCOS2.93
    ./UCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./UCOSII/Ports/: os_cpu_c.c os_cpu_a.c os_cpu.h
    ./UCOSII/Cfg/: app_hooks.c os_cfg.h app_cfg.h
    ./library/: config.h
  group Library
    ./library/: START251.A51 STC32G_Delay.c STC32G_Clock.c
  group DRIVE
    ./: UART.H UART.C
  group TASK
    ./: main.c Visualization.c task.c
  group 使用说明
    ./: 使用说明.txt
