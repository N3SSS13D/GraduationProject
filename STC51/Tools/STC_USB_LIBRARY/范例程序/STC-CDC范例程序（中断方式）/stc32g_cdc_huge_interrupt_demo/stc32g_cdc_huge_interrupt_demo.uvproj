# Keil uVision project stc32g_cdc_huge_interrupt_demo.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: stc32g_cdc_huge_interrupt_demo +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c stc_usb_cdc_32g_huge.LIB
