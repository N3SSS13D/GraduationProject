# Keil uVision project pwm.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: pwm +hex
  group Source Group 1
    ./: WS2812B-PWMA-DMA-24灯环-1通道.c
